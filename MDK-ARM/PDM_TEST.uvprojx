# Keil uVision project PDM_TEST.uvprojx, settings and files
target PDM_TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: PDM_TEST +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_USB_FS
  c include: ../Core/Inc;                 ../PDM2PCM/App;                 ../Drivers/STM32H7xx_HAL_Driver/Inc;                 ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;                 ../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;                 ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;                 ../Drivers/CMSIS/Include;                 ..\APP\Component;                 ..\APP\Main;                 ..\Utilities;                 ..\USB\STM32_USB_Device_Library\Core\Inc;                 ..\USB\STM32_USB_Device_Library\Class\AUDIO\Inc;                 ..\USB\USB_APP
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000400 size 0x1fc00
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dfsdm.c dma.c i2s.c sai.c tim.c usart.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/PDM2PCM/App
    ../PDM2PCM/App/: pdm2pcm.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/PDMFilter
    ../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_Keil_wc16.lib
  group APP/Main
    ../APP/Main/: user_main.c
  group APP/Component
    ../APP/Component/: SAI_Port.c PDM_Datacov.c UART_Port.c Timer_Port.c DFSDM_Port.c I2S_Port.c
  group USB_Core
    ../USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USB_Driver
    ../USB/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio.c
  group USB_App
    ../USB/USB_APP/: stm32h743i_eval_audio.c uac_init.c usbd_audio_if.c usbd_conf.c usbd_desc.c
  group Utilities
    ../Utilities/: utilities_crc.c utilities.c CircularQueue.c
software components: CMSIS:CORE 4.3.0
